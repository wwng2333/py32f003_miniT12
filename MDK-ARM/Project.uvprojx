# Keil uVision project Project.uvprojx, settings and files
target PY32F003x4_Project (6240000::V6.24::ARMCLANG)
  device: PY32F003x4 Puya
  pack: Puya.PY32F0xx_DFP.1.2.9
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: miniT12 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F003x4
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Inc;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x800
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f003xx.s
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_adc.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_dma.c py32f0xx_hal_pwr.c py32f0xx_hal_cortex.c
  group Doc
    ../: readme.txt
target PY32F003x6_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F003x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.9
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x6_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F003x6
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target PY32F003x8_Project (6240000::V6.24::ARMCLANG)
  device: PY32F003x4 Puya
  pack: Puya.PY32F0xx_DFP.1.2.9
  cpu: as above
  output: miniT12 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F003x8
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\PY32F003xx_Start_Kit;..\Inc;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x800
software components: CMSIS:CORE 6.1.1
